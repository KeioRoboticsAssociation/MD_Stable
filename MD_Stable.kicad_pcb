# Repository KeioRoboticsAssociation/MD_Stable

## KiCad design MD_Stable.kicad_pcb

Parts:
C1, C3: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C5, C7, C9, C10, C11, C14, C15, C16, C17, C18, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C48, C49, C50, C51, C52, C53, C54, C55, C56, C58, C59, C60, C61, C62, C63, C64, C80, C81, C82, C83, C84, C85, C86: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C8, C19: 16V 100u; CP_Radial_D5.0mm_P2.00mm
C12, C13: 50v 100u; CP_Radial_D8.0mm_P3.50mm
C20: 16v 100u; CP_Radial_D5.0mm_P2.00mm
C33, C34, C35, C36, C37, C38, C42, C43, C44, C45, C46, C47, C65, C66, C68, C69, C71, C72, C74, C75, C76, C77, C78, C79: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39, C40, C41, C67, C70, C73: 0.22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C57: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D6, D7, D8, D9, D11, D13, D15, D18, D19, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75: 1N4148W; D_SOD-123
D5, D10, D12, D14, D16, D17, D20: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D43, D45, D47: LED_A; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D44, D46, D48: LED_B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Polyfuse; PolyFuse_MF-NSMF-series
J1: XT30_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: XT60_Male; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J3: RE1; PocketHeader_1x05_Horizontal
J4: RE2; PocketHeader_1x05_Horizontal
J5: RE3; PocketHeader_1x05_Horizontal
J6: MO_XT60_Female1; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J7: MO_XT60_Female2; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J8: MO_XT60_Female3; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J9: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal
J10: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Horizontal
J11: FDCAN_1; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: AGM028N08A; PQFN-8-EP_6x5mm_P1.27mm_Generic
R1, R2, R3, R4, R5, R6, R8, R9, R13, R14, R16, R17, R18, R20, R21, R22, R23, R24, R25, R26, R27, R28, R41, R74, R75, R76: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R12, R15, R19: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R48, R49, R50: 24k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29, R30, R31, R32, R33, R34, R42, R43, R44, R45, R46, R47, R56, R57, R58, R59, R60, R61, R68, R69, R70, R71, R72, R73: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R35, R36, R37, R38, R39, R40, R62, R63, R64, R65, R66, R67: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R51, R52, R53, R77: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R54, R55: 240; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW3: SW_Push; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm
SW4, SW5, SW6: PWM; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
SW7, SW8, SW9: DIR; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
U1: NJM7815SDL1; TO-252-2
U2, U4: BA05CC0Tに似た何か; TO-252-2
U3: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U5: BA033CC0FP; TO-252-2
U6: π160M60; SOIC-16W_7.5x10.3mm_P1.27mm
U7, U8, U9: 74AHC1G04W5; SOT-23-5_HandSoldering
U10, U11, U12, U20, U21, U22: 74AHC1G08W5; SOT-23-5_HandSoldering
U13, U14, U15, U17, U18, U19: IR2184; SOIC-8_3.9x4.9mm_P1.27mm
U16: NE555D; SOIC-8_3.9x4.9mm_P1.27mm
U23: MCP2562-E-P; SOP-8_3.76x4.96mm_P1.27mm
Y1: 8MHz; Crystal_HC49-U_Vertical

Connections (part):
555_Out_A: C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C65.2, C66.2, C68.2, C69.2, C71.2, C72.2, U16.3 (Q)
+3V3: C18.1, C20.1, C21.1, C22.1, C83.1, C84.1, D9.2 (A), D21.1 (K), J9.1, R1.2, R8.2, R15.2, SW2.1, SW2.2, SW2.3, U3.1 (VDD), U3.15 (VDDA), U3.17 (VDD), U5.3 (VO), U6.1 (VDD1), U23.5 (Vio)
+5V: C14.1, C19.1, C23.1, D8.2 (A), D19.1 (K), R19.2, R26.1, R27.1, R28.1, R74.1, R75.1, R76.1, U4.3 (VO), U6.16 (VDD2), U7.5 (VCC), U8.5 (VCC), U9.5 (VCC), U10.5 (VCC), U11.5 (VCC), U12.5 (VCC), U20.5 (VCC), U21.5 (VCC), U22.5 (VCC)
+5VD: C7.1, C8.1, C15.1, C16.1, C17.1, C85.1, C86.1, D3.2 (A), D7.1 (K), D9.1 (K), J3.4, J4.4, J5.4, J9.8, J10.1, R12.2, R16.2, R17.2, R18.2, R21.2, R22.2, R23.2, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, U2.3 (VO), U5.1 (VI), U23.3 (VDD)
+12V: C9.1, C12.1, F1.1, J1.2, R10.2
+15V: C5.1, C6.1, C11.1, C30.1, C31.1, C32.1, C64.1, C80.1, C81.1, C82.1, D1.2 (A), D6.1 (K), D8.1 (K), R14.2, R41.1, R54.1, U1.3 (VO), U4.1 (VI), U13.5 (VCC), U14.5 (VCC), U15.5 (VCC), U16.8 (VCC), U17.5 (VCC), U18.5 (VCC), U19.5 (VCC)
DIP_1: R3.2, SW2.4, U3.11 (PA6)
DIP_2: R4.2, SW2.5, U3.10 (PA5)
DIP_3: R5.2, SW2.6, U3.9 (PA4)
DIR1: D2.1 (K), D70.1 (K), J10.2, R2.2, U6.7 (Vif)
DIR2: D4.1 (K), D71.1 (K), J10.4, R6.2, U6.5 (Vid)
DIR3: D13.1 (K), D72.1 (K), J10.6, R13.2, U6.3 (Vib)
FDCAN_RX: U3.21 (PA11), U23.4 (RXD)
FDCAN_TX: U3.22 (PA12), U23.1 (TXD)
GND: C2.2, C5.2, C6.2, C10.2, C11.2, C13.2, C14.2, C19.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C49.1, C51.1, C53.1, C57.2, C59.1, C61.1, C63.1, C64.2, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.2, C81.2, C82.2, D6.2 (A), D12.1 (K), D16.1 (K), D19.2 (A), D20.1 (K), J2.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), Q8.1 (S), Q8.2 (S), Q8.3 (S), Q10.1 (S), Q10.2 (S), Q10.3 (S), Q12.1 (S), Q12.2 (S), Q12.3 (S), R36.1, R38.1, R40.1, R63.1, R65.1, R67.1, U1.2 (GND), U4.2 (GND), U6.9 (GND2), U7.3 (GND), U8.3 (GND), U9.3 (GND), U10.3 (GND), U11.3 (GND), U12.3 (GND)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
GNDD: C1.1, C3.1, C4.2, C7.2, C8.2, C9.2, C12.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C83.2, C84.2, C85.2, C86.2, D5.1 (K), D7.2 (A), D10.1 (K), D14.1 (K), D17.1 (K), D21.2 (A), J1.1, J3.1, J4.1, J5.1, J9.5, J9.12, J10.8, R2.1, R3.1, R4.1, R5.1, R6.1, R9.1, R13.1, R20.1, R24.1, R25.1, SW1.2, SW3.2, U2.2 (GND), U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U5.2 (GND), U6.8 (GND1), U23.2 (VSS), U23.8 (STBY)
LED_1: R7.2, R9.2, U3.31 (PB8)
unnamed: C48.1, R42.1
unnamed: C49.2, R43.2
unnamed: C50.1, R44.1
unnamed: C51.2, R45.2
unnamed: C52.1, R46.1
unnamed: C53.2, R47.2
unnamed: C54.2, R51.2
unnamed: C55.2, R52.2
unnamed: C56.2, R53.2
unnamed: C58.1, R56.1
unnamed: C59.2, R57.2
unnamed: C60.1, R58.1
unnamed: C61.2, R59.2
unnamed: C62.1, R60.1
unnamed: C63.2, R61.2
unnamed: D2.2 (A), U3.13 (PB0)
unnamed: C4.1, D3.1 (K), F1.2, U2.1 (VI)
unnamed: D4.2 (A), U3.26 (PB3)
unnamed: D5.2 (A), R7.1
unnamed: D10.2 (A), R10.1
unnamed: D11.2 (A), U3.20 (PA10)
unnamed: D12.2 (A), R11.1
unnamed: D13.2 (A), U3.25 (PA15)
unnamed: D14.2 (A), R12.1
unnamed: D15.2 (A), U3.19 (PA9)
unnamed: D16.2 (A), R14.1
unnamed: D17.2 (A), R15.1
unnamed: D18.2 (A), U3.18 (PA8)
unnamed: D20.2 (A), R19.1
unnamed: C42.1, D22.1 (K), D23.2 (A)
unnamed: C33.2, D23.1 (K), D24.2 (A)
unnamed: C43.1, D24.1 (K), D25.2 (A)
unnamed: C34.2, C39.2, D25.1 (K), D34.1 (K), U13.8 (VB)
unnamed: C44.1, D26.1 (K), D27.2 (A)
unnamed: C35.2, D27.1 (K), D28.2 (A)
unnamed: C45.1, D28.1 (K), D29.2 (A)
unnamed: C36.2, C40.2, D29.1 (K), D35.1 (K), U14.8 (VB)
unnamed: C46.1, D30.1 (K), D31.2 (A)
unnamed: C37.2, D31.1 (K), D32.2 (A)
unnamed: C47.1, D32.1 (K), D33.2 (A)
unnamed: C38.2, C41.2, D33.1 (K), D36.1 (K), U15.8 (VB)
unnamed: D37.2 (A), Q1.4 (G), R29.2, R35.2
unnamed: D37.1 (K), R29.1, U13.7 (HO)
unnamed: D38.2 (A), Q2.4 (G), R30.2, R36.2
unnamed: D38.1 (K), R30.1, U13.4 (LO)
unnamed: D39.2 (A), Q3.4 (G), R31.2, R37.2
unnamed: D39.1 (K), R31.1, U14.7 (HO)
unnamed: D40.2 (A), Q4.4 (G), R32.2, R38.2
unnamed: D40.1 (K), R32.1, U14.4 (LO)
unnamed: D41.2 (A), Q5.4 (G), R33.2, R39.2
unnamed: D41.1 (K), R33.1, U15.7 (HO)
unnamed: D42.2 (A), Q6.4 (G), R34.2, R40.2
unnamed: D42.1 (K), R34.1, U15.4 (LO)
unnamed: D43.2 (A), D44.1 (K), R48.1
unnamed: D45.2 (A), D46.1 (K), R49.1
unnamed: D47.2 (A), D48.1 (K), R50.1
unnamed: D49.2 (A), Q7.4 (G), R62.2, R68.2
unnamed: D49.1 (K), R68.1, U17.7 (HO)
unnamed: D50.2 (A), Q9.4 (G), R64.2, R69.2
unnamed: D50.1 (K), R69.1, U18.7 (HO)
unnamed: D51.2 (A), Q11.4 (G), R66.2, R70.2
unnamed: D51.1 (K), R70.1, U19.7 (HO)
unnamed: D52.2 (A), Q8.4 (G), R63.2, R71.2
unnamed: D52.1 (K), R71.1, U17.4 (LO)
unnamed: D53.2 (A), Q10.4 (G), R65.2, R72.2
unnamed: D53.1 (K), R72.1, U18.4 (LO)
unnamed: D54.2 (A), Q12.4 (G), R67.2, R73.2
unnamed: D54.1 (K), R73.1, U19.4 (LO)
unnamed: C67.2, C75.2, D55.1 (K), D61.1 (K), U17.8 (VB)
unnamed: C70.2, C77.2, D56.1 (K), D65.1 (K), U18.8 (VB)
unnamed: C73.2, C79.2, D57.1 (K), D69.1 (K), U19.8 (VB)
unnamed: C65.1, D58.1 (K), D59.2 (A)
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
Notes on the sheet:
GND
Hブリッジ
手動回転
ST-Link UART
エンコーダ
駆動部降圧
制御部VCC
G431K8
PWM
CAN
駆動部VCC
I/O
制御部降圧
